# Keil uVision project ble_app_template.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_snr_des_hub +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER
  c misc: --c99
  c include: ..;..\..\..\NordicSDK\Include;..\..\..\NordicSDK\Include\app_common;..\..\..\NordicSDK\Include\ble;..\..\..\NordicSDK\Include\ble\ble_services;..\..\..\NordicSDK\Include\ble\softdevice;..\..\..\CustomSDK\Include\ble\ble_services
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ./../../../NordicSDK/Source/templates/arm/: arm_startup_nrf51.s
    ./../../../NordicSDK/Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    ../../../NordicSDK/Source/ble/ble_services/: ble_srv_common.c
    ../../../CustomSDK/Source/ble/ble_services/: ble_uart.c ble_i2c.c ble_dig.c ble_ana.c ble_conf.c ble_spi.c
  group Libraries
    ../../../NordicSDK/Source/ble/: ble_error_log.c ble_flash.c ble_advdata.c ble_conn_params.c ble_stack_handler.c ble_debug_assert_handler.c
    ../../../NordicSDK/Source/app_common/: app_scheduler.c app_timer.c
    ../../../NordicSDK/Source/simple_uart/: simple_uart.c
    ../../../NordicSDK/Source/twi_master/: twi_sw_master.c
    ../../../NordicSDK/Source/spi_master/: spi_master.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: ble_app_template +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
